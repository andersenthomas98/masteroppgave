# IAR project ble_thread_dyn_mtd_coap_cli_nfc_pca10056_s140.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; APP_UART_DRIVER_INSTANCE=1; BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; ENABLE_FEM; FLOAT_ABI_HARD; MBEDTLS_CONFIG_FILE=<nrf-config.h>; MBEDTLS_USER_CONFIG_FILE=<nrf52840-mbedtls-config.h>; MULTIPROTOCOL_802154_CONFIG_PRESENT; NRF52840_XXAA; NRFX_PRS_ENABLED=0; NRF_SD_BLE_API_VERSION=7; OPENTHREAD_CONFIG_COAP_API_ENABLE; OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=0; OPENTHREAD_CONFIG_FILE=<openthread-config-wrap.h>; OPENTHREAD_MTD=1; S140; SOFTDEVICE_PRESENT; UART0_ENABLED=0; UART1_ENABLED=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\..\components\ble\ble_link_ctx_manager; ..\..\..\..\..\..\..\components\ble\ble_racp; ..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\..\components\ble\ble_services\ble_gls; ..\..\..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_hts; ..\..\..\..\..\..\..\components\ble\ble_services\ble_ias; ..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_lls; ..\..\..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\..\..\..\..\components\ble\ble_services\ble_tps; ..\..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\..\..\..\components\ble\peer_manager; ..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\components\libraries\cli; ..\..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310; ..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\..\..\..\components\libraries\crypto\backend\cifra; ..\..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls; ..\..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\..\..\..\components\libraries\crypto\backend\oberon; ..\..\..\..\..\..\..\components\libraries\crypto\backend\optiga; ..\..\..\..\..\..\..\components\libraries\csense; ..\..\..\..\..\..\..\components\libraries\csense_drv; ..\..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\..\components\libraries\ecc; ..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\components\libraries\experimental_task_manager; ..\..\..\..\..\..\..\components\libraries\fds; ..\..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\..\components\libraries\gfx; ..\..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\..\components\libraries\mpu; ..\..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\..\components\libraries\sdcard; ..\..\..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\..\components\libraries\spi_mngr; ..\..\..\..\..\..\..\components\libraries\stack_guard; ..\..\..\..\..\..\..\components\libraries\stack_info; ..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\components\libraries\svc; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\twi_mngr; ..\..\..\..\..\..\..\components\libraries\twi_sensor; ..\..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\..\components\libraries\usbd\class\audio; ..\..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\..\components\libraries\usbd\class\hid; ..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\..\..\..\..\components\libraries\usbd\class\msc; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser; ..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\common; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec; ..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\..\..\components\nfc\ndef\launchapp; ..\..\..\..\..\..\..\components\nfc\ndef\parser\message; ..\..\..\..\..\..\..\components\nfc\ndef\parser\record; ..\..\..\..\..\..\..\components\nfc\ndef\text; ..\..\..\..\..\..\..\components\nfc\ndef\uri; ..\..\..\..\..\..\..\components\nfc\platform; ..\..\..\..\..\..\..\components\nfc\t2t_lib; ..\..\..\..\..\..\..\components\nfc\t2t_parser; ..\..\..\..\..\..\..\components\nfc\t4t_lib; ..\..\..\..\..\..\..\components\nfc\t4t_parser\apdu; ..\..\..\..\..\..\..\components\nfc\t4t_parser\cc_file; ..\..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure; ..\..\..\..\..\..\..\components\nfc\t4t_parser\tlv; ..\..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\..\..\..\components\softdevice\s140\headers\nrf52; ..\..\..\..\..\..\..\components\thread\utils; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\app_utils; ..\..\..\..\..\..\thread\app_utils; ..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\external\micro-ecc\micro-ecc; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem\three_pin_gpio; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\rsch\raal\softdevice; ..\..\..\..\..\..\..\external\nrf_cc310\include; ..\..\..\..\..\..\..\external\nrf_oberon; ..\..\..\..\..\..\..\external\nrf_oberon\include; ..\..\..\..\..\..\..\external\nrf_security\config; ..\..\..\..\..\..\..\external\nrf_security\include; ..\..\..\..\..\..\..\external\nrf_security\include\mbedtls; ..\..\..\..\..\..\..\external\nrf_security\mbedtls_plat_config; ..\..\..\..\..\..\..\external\nrf_security\nrf_cc310_plat\include; ..\..\..\..\..\..\..\external\openthread\include; ..\..\..\..\..\..\..\external\openthread\project\config; ..\..\..\..\..\..\..\external\openthread\project\nrf52840; ..\..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\..\external\utf_converter; ..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_thread_dyn_mtd_coap_cli_nfc_pca10056_s140.hex
  ILINK.IlinkOutputFile: ble_thread_dyn_mtd_coap_cli_nfc_pca10056_s140.out
  ILINK.IlinkIcfFile: ble_thread_dyn_mtd_coap_cli_nfc_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nrf_cc310
    ../../../../../../../external/nrf_cc310/lib/cortex-m4/hard-float/short-wchar/: libnrf_cc310_0.9.12.a
  group OpenThread
    ../../../../../../../external/openthread/lib/nrf52840/iar/: libopenthread-cli-mtd.a libopenthread-mtd.a libopenthread-nrf52840-transport.a libopenthread-platform-utils.a libopenthread-nrf52840-softdevice-sdk.a libnordicsemi-nrf52840-radio-driver-softdevice.a libopenthread-nrf52840-transport.a libopenthread-platform-utils.a libopenthread-mtd.a
    ../../../../../../../external/nrf_security/lib/: libmbedcrypto_glue_cc310_short_wchar.a libmbedcrypto_glue_short_wchar.a libmbedcrypto_glue_vanilla_short_wchar.a libmbedcrypto_cc310_backend_short_wchar.a libmbedcrypto_vanilla_backend_short_wchar.a libmbedtls_base_vanilla_short_wchar.a libmbedtls_tls_vanilla_short_wchar.a libmbedtls_x509_vanilla_short_wchar.a libnrf_cc310_platform_0.9.2_short_wchar.a libmbedcrypto_glue_cc310_short_wchar.a libmbedcrypto_glue_short_wchar.a libmbedcrypto_glue_vanilla_short_wchar.a libmbedcrypto_cc310_backend_short_wchar.a libmbedcrypto_vanilla_backend_short_wchar.a libmbedtls_base_vanilla_short_wchar.a libmbedtls_tls_vanilla_short_wchar.a libmbedtls_x509_vanilla_short_wchar.a libnrf_cc310_platform_0.9.2_short_wchar.a
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../../components/libraries/ecc/: ecc.c
    ../../../../../../../components/libraries/fds/: fds.c
    ../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_nfct.c nrfx_nvmc.c nrfx_rng.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Thread
    ../../../../../../../components/thread/utils/: thread_utils.c
  group nRF_Crypto backend nRF HW
    ../../../../../../../components/libraries/crypto/backend/nrf_hw/: nrf_hw_backend_init.c nrf_hw_backend_rng.c nrf_hw_backend_rng_mbedtls.c
  group nRF_BLE_Services
    ../../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_thread.c
  group nRF_micro-ecc
    ../../../../../../../external/micro-ecc/nrf52hf_iar/armgcc/: micro_ecc_lib_nrf52.a
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group nRF_Crypto backend CC310
    ../../../../../../../components/libraries/crypto/backend/cc310/: cc310_backend_aes.c cc310_backend_aes_aead.c cc310_backend_chacha_poly_aead.c cc310_backend_ecc.c cc310_backend_ecdh.c cc310_backend_ecdsa.c cc310_backend_eddsa.c cc310_backend_hash.c cc310_backend_hmac.c cc310_backend_init.c cc310_backend_mutex.c cc310_backend_rng.c cc310_backend_shared.c
  group nRF_Crypto backend Oberon
    ../../../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend mbed TLS
    ../../../../../../../components/libraries/crypto/backend/mbedtls/: mbedtls_backend_aes.c mbedtls_backend_aes_aead.c mbedtls_backend_ecc.c mbedtls_backend_ecdh.c mbedtls_backend_ecdsa.c mbedtls_backend_hash.c mbedtls_backend_hmac.c mbedtls_backend_init.c
  group nRF_Oberon_Crypto
    ../../../../../../../external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: liboberon_3.0.3.a
  group nRF_BLE
    ../../../../../../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_lesc.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_NFC
    ../../../../../../../components/nfc/ndef/connection_handover/ac_rec/: nfc_ac_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_oob_advdata/: nfc_ble_oob_advdata.c
    ../../../../../../../components/nfc/ndef/connection_handover/common/: nfc_ble_pair_common.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_pair_lib/: nfc_ble_pair_lib.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_pair_msg/: nfc_ble_pair_msg.c
    ../../../../../../../components/nfc/ndef/connection_handover/ep_oob_rec/: nfc_ep_oob_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/hs_rec/: nfc_hs_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/le_oob_rec/: nfc_le_oob_rec.c
    ../../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../../components/nfc/platform/: nfc_platform.c
    ../../../../../../../components/nfc/t2t_lib/: nfc_t2t_lib_iar.a
  group Example
    ../../../../../../thread/app_utils/: thread_coap_utils.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group nRF_Crypto
    ../../../../../../../components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_aes.c nrf_crypto_aes_shared.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_eddsa.c nrf_crypto_error.c nrf_crypto_hash.c nrf_crypto_hkdf.c nrf_crypto_hmac.c nrf_crypto_init.c nrf_crypto_rng.c nrf_crypto_shared.c
  group None
    ../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
    ../../../../../app_utils/: multiprotocol_802154_config.c
  group UTF8/UTF16 converter
    ../../../../../../../external/utf_converter/: utf.c
