# Keil uVision project ble_thread_dyn_mtd_coap_cli_pca10100_s140.uvprojx, settings and files
target nrf52833_xxaa (ARM-ADS)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack_NordicLicense.8.27.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52833_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED APP_UART_DRIVER_INSTANCE=1 BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET ENABLE_FEM FLOAT_ABI_HARD MBEDTLS_CONFIG_FILE=<mbedtls-config.h> MBEDTLS_USER_CONFIG_FILE=<nrf52833-mbedtls-config.h> MULTIPROTOCOL_802154_CONFIG_PRESENT NRF52833_XXAA NRFX_PRS_ENABLED=0 NRF_SD_BLE_API_VERSION=7 OPENTHREAD_CONFIG_COAP_API_ENABLE OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1 OPENTHREAD_CONFIG_FILE=<openthread-config-wrap.h> OPENTHREAD_MTD=1 S140 SOFTDEVICE_PRESENT UART0_ENABLED=0 UART1_ENABLED=1 __HEAP_SIZE=0 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\..\components\ble\ble_link_ctx_manager;..\..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\..\components\nfc\platform;..\..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\..\components\softdevice\s140\headers;..\..\..\..\..\..\..\components\softdevice\s140\headers\nrf52;..\..\..\..\..\..\..\components\thread\utils;..\..\..\..\..\app_utils;..\..\..\..\..\..\thread\app_utils;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem\three_pin_gpio;..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\rsch\raal\softdevice;..\..\..\..\..\..\..\external\nrf_security\mbedtls_plat_config;..\..\..\..\..\..\..\external\openthread\include;..\..\..\..\..\..\..\external\openthread\mbedtls;..\..\..\..\..\..\..\external\openthread\mbedtls\mbedtls\platform;..\..\..\..\..\..\..\external\openthread\project\config;..\..\..\..\..\..\..\external\openthread\project\nrf52833;..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED APP_UART_DRIVER_INSTANCE=1 BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET ENABLE_FEM FLOAT_ABI_HARD MULTIPROTOCOL_802154_CONFIG_PRESENT NRF52833_XXAA NRFX_PRS_ENABLED=0 NRF_SD_BLE_API_VERSION=7 OPENTHREAD_CONFIG_COAP_API_ENABLE OPENTHREAD_MTD=1 S140 SOFTDEVICE_PRESENT UART0_ENABLED=0 UART1_ENABLED=1 __HEAP_SIZE=0 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DAPP_UART_DRIVER_INSTANCE=1,-DBOARD_PCA10100,-DCONFIG_GPIO_AS_PINRESET,-DENABLE_FEM,-DFLOAT_ABI_HARD,-DMULTIPROTOCOL_802154_CONFIG_PRESENT,-DNRF52833_XXAA,-DNRFX_PRS_ENABLED=0,-DNRF_SD_BLE_API_VERSION=7,-DOPENTHREAD_CONFIG_COAP_API_ENABLE,-DOPENTHREAD_MTD=1,-DS140,-DSOFTDEVICE_PRESENT,-DUART0_ENABLED=0,-DUART1_ENABLED=1,-D__HEAP_SIZE=0,-D__STACK_SIZE=2048
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0x57000
  memory RVCT9: RAM 0x20002ae8 size 0x1d518
  link misc: --diag_suppress 6330
  group None
    ../../../../../app_utils/: multiprotocol_802154_config.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_thread.c
  group Example
    ../../../../../../thread/app_utils/: thread_coap_utils.c
  group OpenThread
    ../../../../../../../external/openthread/lib/nrf52833/keil/: libopenthread-cli-mtd-optimized-mtd.lib libopenthread-mtd-optimized-mtd.lib libopenthread-nrf52833-transport.lib libopenthread-platform-utils-optimized-mtd.lib libmbedcrypto.lib libopenthread-nrf52833-softdevice-sdk-nodiag.lib libnordicsemi-nrf52833-radio-driver-softdevice.lib libopenthread-nrf52833-transport.lib libopenthread-platform-utils-optimized-mtd.lib libopenthread-mtd-optimized-mtd.lib
  group UTF8/UTF16 converter
    ../../../../../../../external/utf_converter/: utf.c
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_nvmc.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_Thread
    ../../../../../../../components/thread/utils/: thread_utils.c
target flash_s140_nrf52_7.0.1_softdevice (ARM-ADS)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: ..
  cpu: as above
  output: s140_nrf52_7.0.1_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=0 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=0 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=0,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0x57000
  memory RVCT9: RAM 0x20002ae8 size 0x1d518
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.27.0
