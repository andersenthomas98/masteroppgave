# IAR project ble_thread_dyn_proximity_usb_pca10056_s140.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; ENABLE_FEM; FLOAT_ABI_HARD; MBEDTLS_CONFIG_FILE=<nrf-config.h>; MBEDTLS_USER_CONFIG_FILE=<nrf52840-mbedtls-config.h>; MULTIPROTOCOL_802154_CONFIG_PRESENT; NRF52840_XXAA; NRFX_PRS_ENABLED=0; NRF_SD_BLE_API_VERSION=7; OPENTHREAD_CONFIG_COAP_API_ENABLE; OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=0; OPENTHREAD_CONFIG_FILE=<openthread-config-wrap.h>; OPENTHREAD_FTD=1; S140; SOFTDEVICE_PRESENT; USBD_POWER_DETECTION=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\..\..\components\ble\ble_db_discovery; ..\..\..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\..\..\components\ble\ble_link_ctx_manager; ..\..\..\..\..\..\..\..\components\ble\ble_racp; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_gls; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hts; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ias; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lls; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\..\..\..\..\..\components\ble\ble_services\ble_tps; ..\..\..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\..\..\..\..\components\ble\nrf_ble_gq; ..\..\..\..\..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\..\..\..\..\components\ble\peer_manager; ..\..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\..\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\..\components\libraries\cli; ..\..\..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\..\..\components\libraries\csense; ..\..\..\..\..\..\..\..\components\libraries\csense_drv; ..\..\..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\..\..\components\libraries\ecc; ..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\..\components\libraries\experimental_task_manager; ..\..\..\..\..\..\..\..\components\libraries\fds; ..\..\..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\..\..\components\libraries\gfx; ..\..\..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\..\..\components\libraries\mpu; ..\..\..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\..\..\components\libraries\sdcard; ..\..\..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\..\..\components\libraries\spi_mngr; ..\..\..\..\..\..\..\..\components\libraries\stack_guard; ..\..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\..\components\libraries\svc; ..\..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\..\components\libraries\twi_mngr; ..\..\..\..\..\..\..\..\components\libraries\twi_sensor; ..\..\..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\..\..\components\libraries\usbd\class\audio; ..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid; ..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\..\..\..\..\..\components\libraries\usbd\class\msc; ..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser; ..\..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec; ..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\common; ..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec; ..\..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\..\..\..\components\nfc\ndef\launchapp; ..\..\..\..\..\..\..\..\components\nfc\ndef\parser\message; ..\..\..\..\..\..\..\..\components\nfc\ndef\parser\record; ..\..\..\..\..\..\..\..\components\nfc\ndef\text; ..\..\..\..\..\..\..\..\components\nfc\ndef\uri; ..\..\..\..\..\..\..\..\components\nfc\platform; ..\..\..\..\..\..\..\..\components\nfc\t2t_lib; ..\..\..\..\..\..\..\..\components\nfc\t2t_parser; ..\..\..\..\..\..\..\..\components\nfc\t4t_lib; ..\..\..\..\..\..\..\..\components\nfc\t4t_parser\apdu; ..\..\..\..\..\..\..\..\components\nfc\t4t_parser\cc_file; ..\..\..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure; ..\..\..\..\..\..\..\..\components\nfc\t4t_parser\tlv; ..\..\..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\..\..\..\..\components\softdevice\s140\headers\nrf52; ..\..\..\..\..\..\..\..\components\thread\utils; ..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\app_utils; ..\..\..\..\..\..\..\thread\app_utils; ..\..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src; ..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem; ..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem\three_pin_gpio; ..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\rsch\raal\softdevice; ..\..\..\..\..\..\..\..\external\nrf_security\config; ..\..\..\..\..\..\..\..\external\nrf_security\include; ..\..\..\..\..\..\..\..\external\nrf_security\mbedtls_plat_config; ..\..\..\..\..\..\..\..\external\nrf_security\nrf_cc310_plat\include; ..\..\..\..\..\..\..\..\external\openthread\include; ..\..\..\..\..\..\..\..\external\openthread\project\config; ..\..\..\..\..\..\..\..\external\openthread\project\nrf52840; ..\..\..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\..\..\external\utf_converter; ..\..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_thread_dyn_proximity_usb_pca10056_s140.hex
  ILINK.IlinkOutputFile: ble_thread_dyn_proximity_usb_pca10056_s140.out
  ILINK.IlinkIcfFile: ble_thread_dyn_proximity_usb_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../../components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../../../../../../../components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../../../components/libraries/fds/: fds.c
    ../../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../../../components/libraries/sensorsim/: sensorsim.c
  group None
    ../../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
    ../../../../../../app_utils/: multiprotocol_802154_config.c
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group OpenThread
    ../../../../../../../../external/openthread/lib/nrf52840/iar/: libopenthread-cli-ftd-optimized-ftd.a libopenthread-ftd-optimized-ftd.a libopenthread-nrf52840-transport-usb.a libopenthread-platform-utils-optimized-ftd.a libopenthread-nrf52840-softdevice-sdk-nodiag.a libnordicsemi-nrf52840-radio-driver-softdevice.a libopenthread-nrf52840-transport-usb.a libopenthread-platform-utils-optimized-ftd.a libopenthread-ftd-optimized-ftd.a
    ../../../../../../../../external/nrf_security/lib/: libmbedcrypto_glue_cc310_short_wchar.a libmbedcrypto_glue_short_wchar.a libmbedcrypto_glue_vanilla_short_wchar.a libmbedcrypto_cc310_backend_short_wchar.a libmbedcrypto_vanilla_backend_short_wchar.a libmbedtls_base_vanilla_short_wchar.a libmbedtls_tls_vanilla_short_wchar.a libmbedtls_x509_vanilla_short_wchar.a libnrf_cc310_platform_0.9.2_short_wchar.a libmbedcrypto_glue_cc310_short_wchar.a libmbedcrypto_glue_short_wchar.a libmbedcrypto_glue_vanilla_short_wchar.a libmbedcrypto_cc310_backend_short_wchar.a libmbedcrypto_vanilla_backend_short_wchar.a libmbedtls_base_vanilla_short_wchar.a libmbedtls_tls_vanilla_short_wchar.a libmbedtls_x509_vanilla_short_wchar.a libnrf_cc310_platform_0.9.2_short_wchar.a
  group nRF_Drivers
    ../../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c
    ../../../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_nvmc.c nrfx_power.c nrfx_saadc.c nrfx_systick.c nrfx_usbd.c
  group Board Support
    ../../../../../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_thread.c
  group Application
    ../../../../: main.c
    ../config/: sdk_config.h
  group nRF_SoftDevice
    ../../../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group nRF_BLE
    ../../../../../../../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../../../../../components/ble/nrf_ble_gq/: nrf_ble_gq.c
  group UTF8/UTF16 converter
    ../../../../../../../../external/utf_converter/: utf.c
  group nRF_BLE_Services
    ../../../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../../../components/ble/ble_services/ble_ias/: ble_ias.c
    ../../../../../../../../components/ble/ble_services/ble_ias_c/: ble_ias_c.c
    ../../../../../../../../components/ble/ble_services/ble_lls/: ble_lls.c
    ../../../../../../../../components/ble/ble_services/ble_tps/: ble_tps.c
  group Example
    ../../../../../../../thread/app_utils/: thread_coap_utils.c
  group nRF_Thread
    ../../../../../../../../components/thread/utils/: thread_utils.c
