# Keil uVision project zigbee_dfu_bootloader_zigbee_dfu_mbr_pca10056.uvprojx, settings and files
target nrf52840_xxaa_mbr (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack_NordicLicense.8.27.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa_mbr +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD MBR_PRESENT NRF52840_XXAA NRF_DFU_SETTINGS_VERSION=2 __HEAP_SIZE=0
  c misc: --reduce_paths -Ospace
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\..\..\components\libraries\crypto\backend\optiga;..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\softdevice\mbr\headers;..\..\..;..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\external\nano-pb;..\..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\..\external\nrf_cc310_bl\include;..\..\..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DMBR_PRESENT,-DNRF52840_XXAA,-DNRF_DFU_SETTINGS_VERSION=2,-D__HEAP_SIZE=0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0xf8000 size 0x6000
  memory RVCT9: RAM 0x20004000 size 0x3bad0
  link misc: --diag_suppress 6330
  group Application
    ../../../../../../dfu/: dfu_public_key.c
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c
  group nRF_Bootloader
    ../../../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    ../../../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend CC310_BL
    ../../../../../../../components/libraries/crypto/backend/cc310_bl/: cc310_bl_backend_ecc.c cc310_bl_backend_ecdsa.c cc310_bl_backend_hash.c cc310_bl_backend_init.c cc310_bl_backend_shared.c
  group nRF_Crypto backend Oberon
    ../../../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_DFU
    ../../../../../../../components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_gpiote.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../components/libraries/util/: app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../../../../../../../external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_3.0.3.lib
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nano-pb
    ../../../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nrf_cc310_bl
    ../../../../../../../external/nrf_cc310_bl/lib/cortex-m4/hard-float/short-wchar/: nrf_cc310_bl_0.9.12.lib
target flash_mbr (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: as above
  cpu: as above
  output: mbr_nrf52_2.4.1_mbr.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: as above
  c misc: --reduce_paths -Ospace
  c include: as above
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0xf8000 size 0x6000
  memory RVCT9: RAM 0x20004000 size 0x3bad0
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.27.0
