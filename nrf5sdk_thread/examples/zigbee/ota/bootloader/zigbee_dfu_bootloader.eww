<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\mbr\iar\zigbee_dfu_bootloader_zigbee_dfu_mbr_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10100\mbr\iar\zigbee_dfu_bootloader_zigbee_dfu_mbr_pca10100.ewp</path>
  </project>  <batchBuild/>
</workspace>