# IAR project zigbee_ota_client_pca10100.ewp, settings and files
configuration nrf52833_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52833_xxaa nRF52833_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10100; BOOTLOADER_START_ADDR=BOOTLOADER_ADDRESS; CONFIG_GPIO_AS_PINRESET; ENABLE_FEM; FLOAT_ABI_HARD; MBR_PRESENT; NRF52833_XXAA; NRF_DFU_SETTINGS_VERSION=2; ZB_TRACE_LEVEL=0; ZB_TRACE_MASK=0; uECC_ENABLE_VLI_API=0; uECC_OPTIMIZATION_LEVEL=3; uECC_SQUARE_FUNC=0; uECC_SUPPORT_COMPRESSED_POINT=0; uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\components\iot\background_dfu; ..\..\..\..\..\..\..\components\iot\background_dfu\transport; ..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\components\libraries\bootloader; ..\..\..\..\..\..\..\components\libraries\bootloader\dfu; ..\..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310; ..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\..\..\..\components\libraries\crypto\backend\cifra; ..\..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls; ..\..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\..\..\..\components\libraries\crypto\backend\oberon; ..\..\..\..\..\..\..\components\libraries\crypto\backend\optiga; ..\..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\..\components\libraries\sha256; ..\..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\..\components\libraries\stack_info; ..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\softdevice\mbr\headers; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\..\components\zigbee\common; ..\..\..\..\..\..\..\components\zigbee\ota; ..\..\..; ..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\external\micro-ecc\micro-ecc; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem; ..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem\three_pin_gpio; ..\..\..\..\..\..\..\external\nano-pb; ..\..\..\..\..\..\..\external\nrf_oberon; ..\..\..\..\..\..\..\external\nrf_oberon\include; ..\..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\..\external\zboss\addons; ..\..\..\..\..\..\..\external\zboss\include; ..\..\..\..\..\..\..\external\zboss\include\ha; ..\..\..\..\..\..\..\external\zboss\include\osif; ..\..\..\..\..\..\..\external\zboss\include\zcl; ..\..\..\..\..\..\..\external\zboss\osif; ..\..\..\..\..\..\..\external\zboss\zb_error; ..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: zigbee_ota_client_pca10100.hex
  ILINK.IlinkOutputFile: zigbee_ota_client_pca10100.out
  ILINK.IlinkIcfFile: zigbee_ota_client_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group nRF_Crypto backend uECC
    ../../../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group Zigbee
    ../../../../../../../external/zboss/lib/iar/: libzboss.a
    ../../../../../../../external/zboss/lib/iar/nrf52833/: nrf_radio_driver.a
    ../../../../../../../external/zboss/zb_error/: zb_error_to_string.c
    ../../../../../../../external/zboss/osif/: zb_nrf52_common.c zb_nrf52_nrf_logger.c zb_nrf52_nvram.c zb_nrf52_sdk_config_deps.c zb_nrf52_timer.c zb_nrf52_transceiver.c
    ../../../../../../../external/zboss/addons/zcl/: zb_zcl_common_addons.c zb_zcl_ota_upgrade_addons.c
  group nano-pb
    ../../../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nRF_Libraries
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../../components/libraries/sha256/: sha256.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/hal/: nrf_ecb.c nrf_nvmc.c
    ../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_rng.c nrfx_systick.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Oberon_Crypto
    ../../../../../../../external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: liboberon_3.0.3.a
  group nRF_Crypto
    ../../../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group Application
    ../../../../../../dfu/: dfu_public_key.c
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_micro-ecc
    ../../../../../../../external/micro-ecc/nrf52hf_iar/armgcc/: micro_ecc_lib_nrf52.a
  group nRF_Crypto backend nRF sw
    ../../../../../../../components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_IoT
    ../../../../../../../components/iot/background_dfu/: background_dfu_block.c background_dfu_operation.c background_dfu_state.c
  group None
    ../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52833.s system_nrf52833.c
  group nRF_DFU
    ../../../../../../../components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
  group nRF_Zigbee
    ../../../../../../../components/zigbee/ota/: zigbee_dfu_transport.c
    ../../../../../../../components/zigbee/common/: zigbee_helpers.c zigbee_logger_eprxzcl.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group nRF_Crypto backend Oberon
    ../../../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
