# IAR project thread_ncp_radio_spi_pca10056e.ewp, settings and files
configuration nrf52811_xxaa (ARM)
  General.OGChipSelectEditMenu: nRF52811_xxaa nRF52811_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; DEVELOP_IN_NRF52840; FLOAT_ABI_SOFT; MBEDTLS_CONFIG_FILE=<mbedtls-config.h>; MBEDTLS_USER_CONFIG_FILE=<nrf52811-mbedtls-config.h>; NRF52811_XXAA; NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3; OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1; OPENTHREAD_CONFIG_FILE=<openthread-config-wrap.h>; OPENTHREAD_RADIO=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\..\external\nrf_security\include; ..\..\..\..\..\..\..\..\external\nrf_security\mbedtls_plat_config; ..\..\..\..\..\..\..\..\external\openthread\include; ..\..\..\..\..\..\..\..\external\openthread\mbedtls; ..\..\..\..\..\..\..\..\external\openthread\mbedtls\mbedtls\platform; ..\..\..\..\..\..\..\..\external\openthread\project\config; ..\..\..\..\..\..\..\..\external\openthread\project\nrf52811; ..\..\..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thread_ncp_radio_spi_pca10056e.hex
  ILINK.IlinkOutputFile: thread_ncp_radio_spi_pca10056e.out
  ILINK.IlinkIcfFile: thread_ncp_radio_spi_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group None
    ../../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52811.s system_nrf52811.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c
    ../../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_nvmc.c nrfx_spis.c
    ../../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group Board Support
    ../../../../../../../../components/libraries/bsp/: bsp.c bsp_thread.c
  group Application
    ../../../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group OpenThread
    ../../../../../../../../external/openthread/lib/nrf52811/iar/: libopenthread-hdlc.a libopenthread-rcp-spi.a libopenthread-spinel-rcp.a libopenthread-nrf52811-transport-spi.a libopenthread-radio.a libopenthread-platform-utils.a libmbedcrypto.a libopenthread-nrf52811-sdk.a libnordicsemi-nrf52811-radio-driver.a libopenthread-nrf52811-transport-spi.a libopenthread-platform-utils.a libopenthread-radio.a
