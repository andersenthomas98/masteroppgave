# IAR project thread_freertos_coap_server_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; ENABLE_FEM; FLOAT_ABI_HARD; FREERTOS; MBEDTLS_CONFIG_FILE=<nrf-config.h>; MBEDTLS_USER_CONFIG_FILE=<nrf52840-mbedtls-config.h>; NRF52840_XXAA; OPENTHREAD_CONFIG_COAP_API_ENABLE; OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=0; OPENTHREAD_CONFIG_FILE=<openthread-config-wrap.h>; OPENTHREAD_FTD=1; UART_ENABLED=0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\thread\utils; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\app_utils; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\freertos\config; ..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52; ..\..\..\..\..\..\external\freertos\portable\IAR\nrf52; ..\..\..\..\..\..\external\freertos\source\include; ..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem; ..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem\three_pin_gpio; ..\..\..\..\..\..\external\nrf_security\config; ..\..\..\..\..\..\external\nrf_security\include; ..\..\..\..\..\..\external\nrf_security\mbedtls_plat_config; ..\..\..\..\..\..\external\nrf_security\nrf_cc310_plat\include; ..\..\..\..\..\..\external\openthread\include; ..\..\..\..\..\..\external\openthread\project\config; ..\..\..\..\..\..\external\openthread\project\nrf52840; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thread_freertos_coap_server_pca10056.hex
  ILINK.IlinkOutputFile: thread_freertos_coap_server_pca10056.out
  ILINK.IlinkIcfFile: thread_freertos_coap_server_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group Third Parties
    ../../../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../external/freertos/source/portable/MemMang/: heap_4.c
    ../../../../../../external/freertos/portable/IAR/nrf52/: port.c
    ../../../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer_freertos.c
    ../../../../../../components/libraries/assert/: assert.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_nvmc.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_thread.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group OpenThread
    ../../../../../../external/openthread/lib/nrf52840/iar/: libopenthread-cli-ftd.a libopenthread-ftd.a libopenthread-nrf52840-transport.a libopenthread-platform-utils.a libopenthread-nrf52840-sdk.a libnordicsemi-nrf52840-radio-driver.a libopenthread-nrf52840-transport.a libopenthread-platform-utils.a libopenthread-ftd.a
    ../../../../../../external/nrf_security/lib/: libmbedcrypto_glue_cc310_short_wchar.a libmbedcrypto_glue_short_wchar.a libmbedcrypto_glue_vanilla_short_wchar.a libmbedcrypto_cc310_backend_short_wchar.a libmbedcrypto_vanilla_backend_short_wchar.a libmbedtls_base_vanilla_short_wchar.a libmbedtls_tls_vanilla_short_wchar.a libmbedtls_x509_vanilla_short_wchar.a libnrf_cc310_platform_0.9.2_short_wchar.a libmbedcrypto_glue_cc310_short_wchar.a libmbedcrypto_glue_short_wchar.a libmbedcrypto_glue_vanilla_short_wchar.a libmbedcrypto_cc310_backend_short_wchar.a libmbedcrypto_vanilla_backend_short_wchar.a libmbedtls_base_vanilla_short_wchar.a libmbedtls_tls_vanilla_short_wchar.a libmbedtls_x509_vanilla_short_wchar.a libnrf_cc310_platform_0.9.2_short_wchar.a
    ../../../../../../external/nrf_security/nrf_cc310_plat/src/: nrf_cc310_platform_abort_freertos.c nrf_cc310_platform_mutex_freertos.c
  group Example
    ../../../../app_utils/: thread_coap_utils.c
  group nRF_Thread
    ../../../../../../components/thread/utils/: thread_utils.c
