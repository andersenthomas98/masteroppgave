# IAR project thread_mqtt_sn_sleepy_subscriber_pca10100.ewp, settings and files
configuration nrf52833_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52833_xxaa nRF52833_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10100; CONFIG_GPIO_AS_PINRESET; ENABLE_FEM; FLOAT_ABI_HARD; MBEDTLS_CONFIG_FILE=<mbedtls-config.h>; MBEDTLS_USER_CONFIG_FILE=<nrf52833-mbedtls-config.h>; NRF52833_XXAA; OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1; OPENTHREAD_CONFIG_FILE=<openthread-config-wrap.h>; OPENTHREAD_MTD=1; UART_ENABLED=0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\thread\mqtt_sn\mqtt_sn_client; ..\..\..\..\..\..\components\thread\utils; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem; ..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem\three_pin_gpio; ..\..\..\..\..\..\external\nrf_security\include; ..\..\..\..\..\..\external\nrf_security\mbedtls_plat_config; ..\..\..\..\..\..\external\openthread\include; ..\..\..\..\..\..\external\openthread\mbedtls; ..\..\..\..\..\..\external\openthread\mbedtls\mbedtls\platform; ..\..\..\..\..\..\external\openthread\project\config; ..\..\..\..\..\..\external\openthread\project\nrf52833; ..\..\..\..\..\..\external\paho\mqtt-sn\mqttsn_packet; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thread_mqtt_sn_sleepy_subscriber_pca10100.hex
  ILINK.IlinkOutputFile: thread_mqtt_sn_sleepy_subscriber_pca10100.out
  ILINK.IlinkIcfFile: thread_mqtt_sn_sleepy_subscriber_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52833.s system_nrf52833.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../components/libraries/assert/: assert.c
    ../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_nvmc.c nrfx_rng.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_thread.c
  group nRF-Thread
    ../../../../../../external/paho/mqtt-sn/mqttsn_packet/: MQTTSNConnectClient.c MQTTSNConnectServer.c MQTTSNDeserializePublish.c MQTTSNPacket.c MQTTSNSearchClient.c MQTTSNSearchServer.c MQTTSNSerializePublish.c MQTTSNSubscribeClient.c MQTTSNSubscribeServer.c MQTTSNUnsubscribeClient.c MQTTSNUnsubscribeServer.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group OpenThread
    ../../../../../../external/openthread/lib/nrf52833/iar/: libopenthread-cli-mtd.a libopenthread-mtd.a libopenthread-nrf52833-transport.a libopenthread-platform-utils.a libmbedcrypto.a libopenthread-nrf52833-sdk.a libnordicsemi-nrf52833-radio-driver.a libopenthread-nrf52833-transport.a libopenthread-platform-utils.a libopenthread-mtd.a
  group nRF_Thread
    ../../../../../../components/thread/mqtt_sn/mqtt_sn_client/: mqttsn_client.c mqttsn_gateway_discovery.c mqttsn_packet_fifo.c mqttsn_packet_receiver.c mqttsn_packet_sender.c mqttsn_platform.c mqttsn_transport_ot.c
    ../../../../../../components/thread/utils/: thread_utils.c
