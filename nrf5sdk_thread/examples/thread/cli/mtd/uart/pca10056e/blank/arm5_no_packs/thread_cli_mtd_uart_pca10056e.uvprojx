# Keil uVision project thread_cli_mtd_uart_pca10056e.uvprojx, settings and files
target nrf52811_xxaa (ARM-ADS)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack_NordicLicense.8.27.0
  cpu: IROM(0x00000000,0x30000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M4") CLOCK(64000000) ELITTLE
  output: nrf52811_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52840 ENABLE_FEM FLOAT_ABI_SOFT MBEDTLS_CONFIG_FILE=<mbedtls-config.h> MBEDTLS_USER_CONFIG_FILE=<nrf52811-mbedtls-config.h> NRF52811_XXAA NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1 OPENTHREAD_CONFIG_FILE=<openthread-config-wrap.h> OPENTHREAD_MTD=1 UART0_ENABLED=0 __HEAP_SIZE=0 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\thread\utils;..\..\..;..\..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem;..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem\three_pin_gpio;..\..\..\..\..\..\..\..\external\nrf_security\mbedtls_plat_config;..\..\..\..\..\..\..\..\external\openthread\include;..\..\..\..\..\..\..\..\external\openthread\mbedtls;..\..\..\..\..\..\..\..\external\openthread\mbedtls\mbedtls\platform;..\..\..\..\..\..\..\..\external\openthread\project\config;..\..\..\..\..\..\..\..\external\openthread\project\nrf52811;..\..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET DEVELOP_IN_NRF52840 ENABLE_FEM FLOAT_ABI_SOFT NRF52811_XXAA NRFX_COREDEP_DELAY_US_LOOP_CYCLES=3 OPENTHREAD_MTD=1 UART0_ENABLED=0 __HEAP_SIZE=0 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DDEVELOP_IN_NRF52840,-DENABLE_FEM,-DFLOAT_ABI_SOFT,-DNRF52811_XXAA,-DNRFX_COREDEP_DELAY_US_LOOP_CYCLES=3,-DOPENTHREAD_MTD=1,-DUART0_ENABLED=0,-D__HEAP_SIZE=0,-D__STACK_SIZE=2048
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2e000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: --diag_suppress 6330
  group Application
    ../../../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../../components/libraries/bsp/: bsp.c bsp_thread.c
  group OpenThread
    ../../../../../../../../external/openthread/lib/nrf52811/keil/: libopenthread-cli-mtd.lib libopenthread-mtd.lib libopenthread-nrf52811-transport.lib libopenthread-platform-utils.lib libmbedcrypto.lib libopenthread-nrf52811-sdk.lib libnordicsemi-nrf52811-radio-driver.lib libopenthread-nrf52811-transport.lib libopenthread-platform-utils.lib libopenthread-mtd.lib
  group nRF_Drivers
    ../../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c
    ../../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_nvmc.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../../../components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_Thread
    ../../../../../../../../components/thread/utils/: thread_utils.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.27.0
